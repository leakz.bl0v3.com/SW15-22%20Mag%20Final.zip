S&W15-22 Final Release (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Locking Plate", "Left", "Right"